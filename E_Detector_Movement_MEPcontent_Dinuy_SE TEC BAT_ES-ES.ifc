Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2025-11-06T14:54:52+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; S4R_Use_nominal_diameter: yes; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: E_Detector_Movement_MEPcontent_Dinuy_SE TEC BAT_ES-ES:SE TEC BAT, E_Detector_Movement_MEPcontent_Dinuy_SE TEC BAT_ES-ES:SE TEC BAT:1656671
In: F00
Type - Material: Color RAL 9002, Color RGB 080-080-080
Type - Constraints - Default Elevation: 0 mm
Type - Data - Frequency: 50/60 Hz; Maximum Operating Temperature: 35 C; Mounting: Ceiling; Mounting Height (m): 2.5
Type - Dimensions - Depth: 53 mm; Height: 34 mm; Rotation U-Axis Correction: 180 deg; Rotation V-Axis Correction: 180 deg; Rotation W-Axis Correction: 0 deg; Sensor Diameter: 80 mm; Sensor Height: 63.5 mm; Width: 108 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: Batería para luminaria de emergencia, montado en el techo; Article Type: SE TEC BAT; Base Family Version: 25.12; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Batería para luminaria de emergencia, montado en el techo; EMCS Version: 5.0; ETIM Article Class: EC000133; Family Version: 25.12; GLN: 8422447000009; GTIN: 8422447018523; Manufacturer: Dinuy; Manufacturer Art. No.: SE TEC BAT; Manufacturer URL: https://dinuy.com/en; MEPcontent Class: DETECTOR_MOVEMENT; Model: SE TEC BAT; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: Dinuy; Revit Version: 2023; Type Name: SE TEC BAT; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Weight: 0.104 kg
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Communication Devices; Family Name: E_Detector_Movement_MEPcontent_Dinuy_SE TEC BAT_ES-ES
Type - Pset_BuildingElementProxyCommon - IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Dinuy
Pset_BuildingElementProxyCommon - Reference: SE TEC BAT
Pset_EnvironmentalImpactIndicators - Reference: SE TEC BAT
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.0094964 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000146692 m3
Identity Data - Mark: 1
Other - Family: E_Detector_Movement_MEPcontent_Dinuy_SE TEC BAT_ES-ES; Family and Type: E_Detector_Movement_MEPcontent_Dinuy_SE TEC BAT_ES-ES: SE TEC BAT; Type: SE TEC BAT; Type Id: 1656656
Phasing - Phase Created: 4. Plan over 10 years

# IfcDistributionPort, Port_1656671
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE; SystemType: VENTILATION
